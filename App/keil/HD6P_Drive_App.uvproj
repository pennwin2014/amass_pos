# Keil uVision project HD6P_Drive_App.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2134 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: test +hex
  c flags: Optim=1 wLevel=2
  c define: __DEBUG_FLASH
  asm define: __DEBUG_FLASH
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: ..\src\mem_c.scf
  link misc: --entry 0x00000000
  group Source Group 1
    ../src/: main.c flash_store.c menu.h menu.c sp_info.h sp_info.c
    ../../: HD6P_Lib.lib
